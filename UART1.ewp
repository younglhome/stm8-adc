# IAR project UART1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S001
  ICCSTM8.CCDiagSuppress: pe550,pe177
  ICCSTM8.CCIncludePath2: Bsp; StdPeriph_Driver\inc; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: adc.s19
  ILINK.IlinkOutputFile: UART1.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Bsp
    Bsp/: adc1.c key.c led.c tim4.c tm1652.c uart1.c
  group StdPeriph_Driver
    StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group User
    User/: main.c stm8s_it.c
